## downloads/code/hello/Kconfig
```kconfig
config HELLO
	tristate "Frist Android Driver"
	default y
	help
	This is the first android driver.
```
